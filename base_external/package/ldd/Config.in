## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "snull"
	help
	  Includes snull kernel module in the kernel image.
```
